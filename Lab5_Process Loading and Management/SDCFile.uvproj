# Keil uVision project SDCFile.uvproj, settings and files
target SDCFile (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SDCFile
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s diskio.c ff.c PLL.c SDCFile.c loader.c heap.c UART2.c OS.c ST7735.c OSasm.s Interpreter.c EdgeTriggered.c LinkedList.c
