# Keil uVision project Proc.uvproj, settings and files
target Proc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Proc
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --split --edit=import.stf
  group Source
    ./: startup.s Proc.c osasm.s Display.s
  group Symbols
    ../Lab5_4F120/: Lab5.def
